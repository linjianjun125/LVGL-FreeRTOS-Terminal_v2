# Keil uVision project atk_h743.uvprojx, settings and files
target LED (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h743 +hex
  AfterMake: fromelf --bin -o ../../Output/atk_h743.bin ../../Output/atk_h743.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32H743xx
  c misc: --no-multibyte-chars
  c include: ..\..\Start\CMSIS;..\..\User;..\..\System;..\..\Config;..\..\UI;..\..\APP;..\..\Devices;..\..\Middle;..\..\Middle\freertos\include;..\..\Middle\freertos\portable\RVDS\ARM_CM7\r0p1;..\..\Middle\audio\flac;..\..\Lvgl\lvgl\src;..\..\Lvgl\lvgl;..\..\Lvgl\lvgl\examples\porting
  memory RVCT4: ROM 0x8020000 size 0x1e0000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group StartUp
    ../../Start/CMSIS/: startup_stm32h743xx.s
  group User
    ../../Devices/: devices_include.h
    ../../Middle/: middle_include.h
    ../../UI/: ui_include.h
    ../../APP/: app_include.h
    ../../User/: FreeRTOSConfig.h main.c
    ../../Lvgl/lvgl/: lv_conf.h
  group Config
    ../../Config/: config.h config_rcc.h config_rcc.c config_gpio.h config_gpio.c config_nvic.h config_nvic.c config_spi.h config_usart.h config_dma.h config_sai.h
  group System
    ../../System/: sys.h sys.c
    ../../System/debug/: debug.h debug.c
    ../../System/delay/: delay.h delay.c
  group Task
    ../../APP/task/: freertos_task.h freertos_task.c ui_key_task.c music_task.c volume_backlight_task.c sensor_imu_rtc.c wifi_task.c
  group Service
    ../../APP/service/: firmware_service.h firmware_service.c sensor_hub.h sensor_hub.c at24cxx_data.h at24cxx_data.c music_service.h music_service.c volume_service.h volume_service.c backlight_service.h backlight_service.c novel_service.h novel_service.c wifi_service.h wifi_service.c led_service.h led_service.c
  group UI
    ../../UI/: screen.h screen.c
  group UI/fonts
    ../../UI/_fonts/: _lvgl_big_number_font.c _lvgl_music_cd_img_200_200.c _lvgl_font1.c _lvgl_font2.c _lvgl_font3.c _lvgl_font4.c
  group UI/screen_ex
    ../../UI/calculator_screen/ex/: tinyexpr.h tinyexpr.c
    ../../UI/game2048_screen/ex/: game2048.h game2048.c
    ../../UI/snake_screen/ex/: snake.h snake.c
    ../../UI/tetris_screen/ex/: tetris.h tetris.c
    ../../UI/novel_screen/ex/: novel.h novel.c
  group UI/screen
    ../../UI/top_screen/: top_screen.h top_screen.c
    ../../UI/music_screen/: music_screen.c music_select_screen.c
    ../../UI/app_select_screen/: app_select_screen.c
    ../../UI/game_select_screen/: game_select_screen.c
    ../../UI/tetris_screen/: tetris_screen.c
    ../../UI/snake_screen/: snake_screen.c
    ../../UI/game2048_screen/: game2048_screen.c
    ../../UI/tool_select_screen/: tool_select_screen.c
    ../../UI/calculator_screen/: calculator_screen.c
    ../../UI/level_screen/: level_screen.c
    ../../UI/stopwatch_screen/: stopwatch_screen.c
    ../../UI/battery_screen/: battery_screen.c
    ../../UI/file_screen/: file_screen.c
    ../../UI/system_screen/: system_screen.c system_screen_ex.c
    ../../UI/novel_select_screen/: novel_select_screen.c
    ../../UI/novel_screen/: novel_screen.c
    ../../UI/calendar_screen/: calendar_screen.c
    ../../UI/weather_screen/: weather_screen.c
  group Mid/fatfs
    ../../Middle/fatfs/: ffconf.h ff.h ff.c diskio.h diskio.c ffunicode.c
  group Mid/fonts
    ../../Middle/fonts/: fonts.h fonts.c
  group Mid/malloc
    ../../Middle/malloc/: malloc.h malloc.c
  group Mid/linklist
    ../../Middle/linklist/: linkList.c
    ../../Middle/list/: list.h musiclist.h musiclist.c
  group Mid/cjson
    ../../Middle/cjson/: cJSON.h cJSON.c
  group Mid/freertos/core
    ../../Middle/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middle/freertos/include/: semphr.h
  group Mid/freertos/port
    ../../Middle/freertos/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../Middle/freertos/portable/MemMang/: heap_4.c
  group Mid/audio/wav
    ../../Middle/audio/wav/: wav.h wav.c
  group Mid/audio/mp3
    ../../Middle/audio/mp3/: mp3.c mp3.h
    ../../Middle/audio/mp3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../../Middle/audio/mp3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group Mid/audio/flac
    ../../Middle/audio/flac/: flac.c flac.h
    ../../Middle/audio/flac/flacdec/: golomb.h flacdecoder.h flacdecoder.c bitstreamf.h bitstreamf.c tables.c
  group Mid/audio/ape
    ../../Middle/audio/ape/apedec/: parser.h parser.c apedecoder.h apedecoder.c entropy.h entropy.c filter_16_11.c filter_32_10.c filter_64_11.c predictor.c predictor-arm.S
    ../../Middle/audio/ape/: ape.c ape.h
  group Devices/sys
    ../../Devices/mpu/: mpu.c mpu.h
    ../../Devices/rtc/: rtc_alarm.c rtc_alarm.h rtc_init.c rtc_init.h rtc_time.c rtc_time.h
    ../../Devices/random/: random.c random.h
  group Devices/key
    ../../Devices/key/: key.h key.c
  group Devices/led
    ../../Devices/led/: led.h led.c
  group Devices/sensor
    ../../Devices/sensor/: sensor_spi.h sensor_spi.c sensor_spi_port.h sensor_spi_port.c sensor_iic.h sensor_iic.c sensor_iic_port.h sensor_iic_port.c icm42688.c qmc5883.c bh1750.c sht30.c sensor.c
  group Devices/max17048
    ../../Devices/power/: max17048_iic.h max17048_iic.c max17048_port.h max17048_port.c max17048.h max17048.c
  group Devices/sdmmc
    ../../Devices/sdmmc/: sdcard_define.h sdmmc_sdcard.h sdmmc_sdcard.c
  group Devices/sdram
    ../../Devices/sdram/: sdram.h sdram.c
  group Devices/nor_flash
    ../../Devices/nor_flash/: norflash_qspi.c norflash.c
  group Devices/at24cxx
    ../../Devices/at24cxx/: at24cxx_iic.h at24cxx_iic.c at24cxx_port.h at24cxx_port.c at24cxx.h at24cxx.c
  group Devices/wifi
    ../../Devices/wifi/: wifi_uart.h wifi_uart.c
  group Devices/lcdrgb
    ../../Devices/lcdrgb/: lcdrgb_init.h lcdrgb_init.c lcdrgb_ltdc.h lcdrgb_ltdc.c lcdrgb_dma2d.h lcdrgb_dma2d.c lcdrgb_blk.h lcdrgb_blk.c lcdrgb.h lcdrgb.c
  group Devices/touch
    ../../Devices/touch/: touch_iic.h touch_iic.c touch.h touch.c
  group Devices/audio
    ../../Devices/audio/: audio_es8388_iic.h audio_es8388_iic.c audio_es8388.h audio_es8388.c audio_dma.h audio_dma.c audio_sai.h audio_sai.c
  group Device/audio/decode
    ../../Devices/audio/decode/: decode.h decode.c decode_wav.c decode_mp3.c decode_flac.c
  group Lvgl/port
    ../../Lvgl/lvgl/examples/porting/: lv_port_disp_template.h lv_port_disp_template.c lv_port_indev_template.h lv_port_indev_template.c
  group Lvgl/core
    ../../Lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Lvgl/hal
    ../../Lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Lvgl/misc
    ../../Lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Lvgl/draw
    ../../Lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.h lv_gpu_stm32_dma2d.c
    ../../Lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group Lvgl/font
    ../../Lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Lvgl/widgets
    ../../Lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Lvgl/extra
    ../../Lvgl/lvgl/src/extra/: lv_extra.c
    ../../Lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
  group Lvgl/extra_widgets
    ../../Lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
